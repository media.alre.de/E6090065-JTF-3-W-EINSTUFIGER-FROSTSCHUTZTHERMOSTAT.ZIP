Properties of the parts of a building model (IFC2X3)

# File
Description: Frostschutz-Thermostat, Kapillarlänge 1,8 m, Inneneinstellung, ViewDefinition[CoordinationView]
File name: ifc-2x3.ifc
Time: 2026-04-23T13:34:05+0000
Author: ALRE-IT Regeltechnik GmbH, mail@alre.de
Organization: ALRE-IT Regeltechnik GmbH, Richard-Tauber-Damm 10, 12277 Berlin, +49 30 39984-0, https://alre.de
Written by: 2.0.0
Made in: ALRE-IT BMEcat2IFC Exporter
Authorization: N/A

# IfcBuildingStorey, Geschoss
In: Gebaeude
Elevation: 0 m

# IfcBuildingElementProxy: E6090065, Frostschutz-Thermostat, Kapillarlänge 1,8 m, Inneneinstellung
In: Raum
Description: Zur Sicherung von Warmwasserheizregistern gegen Einfrieren. Das Gerät ist eigensicher und hat eine plombierbare Sollwerteinstellung. Für Temperaturmessung nicht aggressiver Gase im Kanal ist die Schutzwendel SW-200–12, für Temperaturmessung in nicht aggressiven Fluiden ist die Tauchhülse TH-140, in aggressiven Fluiden die Tauchhülse NTH-140 zu verwenden. Montageklammern, Tauchhülsen und Schutzwendel gehören nicht zum Lieferumfang und müssen separat bestellt werden.; Classification: EC011174 ETIM-Klasse (ETIM)
Pset_ManufacturerTypeInformation - Manufacturer: ALRE-IT Regeltechnik GmbH; ModelReference: E6090065; ModelLabel: JTF-3 W; GlobalTradeItemNumber: 4050528030214; ProductURL: https://alre.de/produkt_E6090065
Pset_Specification - NominalLength: 0.2 m; NominalWidth: 0.12 m; NominalDepth: 0.075 m; NetWeight: 0.857
Pset_ALRE_ETIM_Properties - Breite: 120; Höhe: 200; Tiefe: 75; Messbereich: 10; Explosionsgeschützt: no; Schutzart (IP): IP65; Max. Mediumtemperatur (Dauerbetrieb): 200; Länge Kapillar: 1.8; Max. Spannung der Kontakte: 230; Kontaktverriegelung: no; Max. Kontaktbelastung: 15; Schaltdifferenz einstellbar: no; ETIM-Klasse: EC011174; ETIM-Version: ETIM-10.0
Pset_ALRE_Dokumente - Datenblatt: https://media.alre.de/deu_DEU/datasheet/ALRE_Datenblatt-E6090065.pdf
